# Keil uVision project Little-Remote.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: Little-Remote +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Libraries\Public;..\Libraries\GPIO;..\Libraries\ADC;..\Libraries\PWM;..\Libraries\Compare;..\Libraries\FlashRom;..\Libraries\TouchKey;..\Libraries\Timer;..\Libraries\SPI
  link misc: REMOVEUNUSED
  group Libraries
    ../Libraries/Public/: DEBUG.C
    ../Libraries/GPIO/: GPIO.C
    ../Libraries/PWM/: PWM.C
    ../Libraries/ADC/: ADC.C
    ../Libraries/FlashRom/: FlashRom.C
    ../Libraries/SPI/: SPI.C
    ../Libraries/Timer/: Timer.C
  group User
    ../User/: main.c drv_RF24L01.c tools.c XboxUSB.c HidUSB.c para.c
